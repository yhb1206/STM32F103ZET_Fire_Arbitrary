# Keil uVision project iSO-STM32.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Ethernet\Internet;..\..\User\Ethernet\W5500;..\..\User\usart;..\..\User\led;..\..\User\I2C_EEPROM;..\..\User\TimBase;..\..\User\bsp_dht11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/usart/: bsp_usart1.c bsp_usart1.h
    ../../User/led/: bsp_led.c bsp_led.h
    ../../User/I2C_EEPROM/: bsp_i2c_ee.c bsp_i2c_ee.h bsp_i2c_gpio.c bsp_i2c_gpio.h
    ../../User/TimBase/: bsp_TiMbase.c bsp_TiMbase.h
    ../../User/bsp_dht11/: bsp_dht11.c bsp_dht11.h
  group W5500
    ../../User/Ethernet/W5500/: w5500_conf.c w5500_conf.h w5500.c w5500.h socket.c socket.h utility.c utility.h types.h
  group Internet
    ../../User/Ethernet/Internet/: dhcp.c dhcp.h http_client.c http_client.h
software components: CMSIS:CORE 4.2.0
