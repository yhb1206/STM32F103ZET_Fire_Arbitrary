# Keil uVision project project.uvproj, settings and files
target RT-Thread/STM32 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32 +hex
  c flags: Optim=1 wLevel=2
  c include: .;.\library\inc;.\library\src;..\..\include;..\..\libcpu\arm\stm32;..\..\finsh;..\..\rtgui\include;..\..\filesystem\dfs;..\..\filesystem\dfs\include;..\..\net\lwip\src;..\..\net\lwip\src\include;..\..\net\lwip\src\arch\include;..\..\net\lwip\src\include\ipv4;..\..\filesystem\dfs\include;..\..\filesystem\dfs\filesystems\efsl\src\include;..\..\filesystem\dfs\filesystems\efsl\src\base\include;..\..\filesystem\dfs\filesystems\efsl\src\fs\vfat\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Startup
    ./: application.c board.c startup.c cortexm3_macro.s stm32f10x_it.c stm32f10x_conf.h rtconfig.h usart.c sdcard.c enc28j60.c rtc.c
  group Library
    ./library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Kernel
    ../../src/: clock.c idle.c ipc.c mem.c mempool.c object.c scheduler.c thread.c timer.c irq.c kservice.c device.c slab.c
  group STM32
    ../../libcpu/arm/stm32/: stack.c interrupt.c cpu.c serial.c context_rvds.S start_rvds.s fault.c fault_rvds.S
  group finsh
    ../../finsh/: finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c cmd.c
  group Filesystem
    ../../filesystem/dfs/src/: dfs_init.c dfs_fs.c dfs_raw.c dfs_util.c dfs_cache.c dfs_posix.c
    ../../filesystem/dfs/filesystems/efsl/src/base/: efs.c extract.c partition.c plibc.c
    ../../filesystem/dfs/filesystems/efsl/src/fs/vfat/: dir.c fat.c file.c fs.c ls.c time.c ui.c
  group LwIP
    ../../net/lwip/src/core/: dhcp.c dns.c init.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c memp_tiny.c
    ../../net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../net/lwip/src/core/snmp/: msg_in.c msg_out.c
    ../../net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c sockets.c
    ../../net/lwip/src/netif/: etharp.c ethernetif.c loopif.c
    ../../net/lwip/src/arch/: sys_arch_init.c sys_arch.c
  group GoAhead
    ../../net/webserver/: websuemf.c asp.c balloc.c base64.c default.c ejlex.c ejparse.c emfdb.c form.c h.c handler.c mime.c misc.c page.c ringq.c rom.c security.c sock.c sockGen.c sym.c uemf.c um.c umui.c url.c value.c webs.c
    ../../net/webserver/RTT/: main.c
